# Autodesk Inventor part: Back Plate
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2022-08
Part Number: Back Plate
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Back Plate
Author: Administrator
## Design history (mm, degrees)
feature "Back Plate"
body "Solid1"
